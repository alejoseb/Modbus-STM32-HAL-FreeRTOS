<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F429I-DISCO.ewp</path>
  </project>
  <batchBuild />
</workspace>
